FILESEXTRAPATHS_prepend := "${THISDIR}/gcc:"

SRC_URI += "file://0001-expand-size.patch"

