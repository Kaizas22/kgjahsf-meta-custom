KMACHINE_my-qemux86-64 ?= "qemux86-64"
KMACHINE_my-qemuarm ?= "qemuarm"
