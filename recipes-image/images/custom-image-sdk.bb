require recipes-image/images/custom-image-base.bb

ARP_DEVICE ?= "HRHR256"


#inherit populate_sdk_qt5
#EXTRA_OEMAKE_append = "\
#    '-DUNICODE' \
#"
