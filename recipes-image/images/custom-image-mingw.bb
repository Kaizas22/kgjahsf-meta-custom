require recipes-image/images/custom-image-base.bb
