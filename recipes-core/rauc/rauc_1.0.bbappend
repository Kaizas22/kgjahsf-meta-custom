FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-bootchooser-correct-path-for-fw_setenv-on-target.patch"

